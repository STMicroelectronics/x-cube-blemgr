# Keil uVision project SensorDataTransmit.uvprojx, settings and files
target SensorDataTransmit (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.4
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: SensorDataTransmit +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c misc: -Wno-format
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/Third_Party/parson;../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;../../../../../../Middlewares/ST/STM32WB07_06/utils;../../../../../../Middlewares/ST/STM32WB07_06/includes;../../../../../../Middlewares/ST/STM32WB07_06/hci/hci_tl_patterns/Basic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c ble_implementation.c hci_tl_interface.c app_blemgr.c steval_mkboxpro_bus.c steval_mkboxpro.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Led
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_led.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/SensorFusion
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_sensor_fusion.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_manager.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/Utils
    ../../../../../../Middlewares/ST/STM32WB07_06/utils/: ble_list.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/Controller
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/controller/: stm32wb07_06_gap_aci.c stm32wb07_06_gatt_aci.c stm32wb07_06_hal_aci.c stm32wb07_06_l2cap_aci.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/HCI_TL/Basic
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/: stm32wb07_06_dev_config.c stm32wb07_06_events.c stm32wb07_06_events_cb.c stm32wb07_06_hci_le.c
software components: CMSIS:CORE 4.3.0
