# IAR project SensorDataTransmit.ewp, settings and files
configuration SensorDataTransmit (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/parson; ../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../../Middlewares/ST/STM32WB07_06/utils; ../../../../../../Middlewares/ST/STM32WB07_06/includes; ../../../../../../Middlewares/ST/STM32WB07_06/hci/hci_tl_patterns/Basic
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorDataTransmit.bin
  ILINK.IlinkOutputFile: SensorDataTransmit.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: app_blemgr.c ble_implementation.c hci_tl_interface.c main.c steval_mkboxpro.c steval_mkboxpro_bus.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_manager.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Led
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_led.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/SensorFusion
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_sensor_fusion.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/Controller
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/controller/: stm32wb07_06_gap_aci.c stm32wb07_06_gatt_aci.c stm32wb07_06_hal_aci.c stm32wb07_06_l2cap_aci.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/HCI_TL/Basic
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../../Middlewares/ST/STM32WB07_06/hci/: stm32wb07_06_dev_config.c stm32wb07_06_events.c stm32wb07_06_events_cb.c stm32wb07_06_hci_le.c
  group Middlewares/STM32WB07_06/Wireless/STM32WB07_06/Utils
    ../../../../../../Middlewares/ST/STM32WB07_06/utils/: ble_list.c
